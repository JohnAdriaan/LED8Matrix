# Keil uVision project LED8x8.uvproj, settings and files
target STC12 (MCS-51)
  device: STC12C5A60S2 STC12C5A16S2 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000)
  output: LED8x8 +hex
  c flags: Optimize=8 SizeSpeed=1
  asm include: ./Includes
  link misc: IXREF NOSORTSIZE REMOVEUNUSED PAGEWIDTH(80) PAGELENGTH(999999)
  group Source
    ./Source/: Vector.a51 Main.a51 CPU.a51 UART.a51 Timer.a51 DigiPot.a51 LED.a51
  group Listings
    ./Listings/: LED8x8.map
    ./Objects/: LED8x8.hex
    ./: Naming.txt
  group Includes
    ./Includes/: AUXR.inc IE.inc PCON.inc WDT.inc TCON.inc PSW.inc P0.inc P1.inc P2.inc P3.inc P4.inc
